# Keil uVision project pixhawk4CubeMX.uvprojx, settings and files
target pixhawk4CubeMX (ARM-ADS)
  device: STM32F765IIKx STMicroelectronics
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: pixhawk4CubeMX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F765xx
  c include: ../Core/Inc;    ../USB_DEVICE/App;    ../USB_DEVICE/Target;    ../Drivers/STM32F7xx_HAL_Driver/Inc;    ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;    ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;    ../Drivers/CMSIS/Include
  group Application/MDK-ARM
    ./: startup_stm32f765xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c i2c.c sdmmc.c spi.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_gpio.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c stm32f7xx_ll_rcc.c stm32f7xx_ll_utils.c stm32f7xx_ll_exti.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_ll_adc.c stm32f7xx_ll_dma.c stm32f7xx_hal_can.c stm32f7xx_ll_i2c.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_ll_spi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
